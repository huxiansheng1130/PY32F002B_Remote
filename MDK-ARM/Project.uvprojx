# Keil uVision project Project.uvprojx, settings and files
target PY32F002Bx5_Project (6190000::V6.19::ARMCLANG)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: PY32F002Bx5,USE_FULL_LL_DRIVER
  c include: ..\Projects;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\PY32F002B\Include;..\Drivers\PY32F002B_LL_BSP\Inc;..\Drivers\PY32F002B_LL_Driver\Inc;..\Projects\drivers\i2c_module;..\Projects\keyboard_module;..\Projects\function_module;..\Projects\gyro_module;..\Projects\i2c_module;..\Projects\keyboard_module;..\Projects\led_module;..\Projects\ntc_module;..\Projects\power_module;..\Projects\rf_433_module;..\Projects\flash_module
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Application/User
    ../Projects/flash_module/: flash_handle.c
    ../Projects/function_module/: function_handle.c
    ../Projects/gyro_module/: qmi8658a_driver.c qmi8658a_handle.c
    ../Projects/keyboard_module/: keyboard_driver.c keyboard_handle.c
    ../Projects/led_module/: led_driver.c
    ../Projects/ntc_module/: ntc_driver.c ntc_handle.c
    ../Projects/power_module/: power_driver.c
    ../Projects/rf_433_module/: 433_protocol.c 433_send_driver.c
    ../Projects/: app.c main.c
    ../Projects/drivers/i2c_module/: i2c_driver.c
  group Common
    ./: startup_py32f002bxx.s
    ../Drivers/CMSIS/Device/PY32F002B/Source/: py32f002b_it.c system_py32f002b.c
  group Driver/PY32F002B_BSP
    ../Drivers/PY32F002B_LL_BSP/Src/: py32f002b_bsp_clock.c py32f002b_bsp_printf.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group Drivers/PY32F002B_LL_Driver
    ../Drivers/PY32F002B_LL_Driver/Src/: py32f002b_ll_adc.c py32f002b_ll_comp.c py32f002b_ll_crc.c py32f002b_ll_exti.c py32f002b_ll_flash.c py32f002b_ll_gpio.c py32f002b_ll_i2c.c py32f002b_ll_lptim.c py32f002b_ll_pwr.c py32f002b_ll_rcc.c py32f002b_ll_spi.c py32f002b_ll_tim.c py32f002b_ll_usart.c py32f002b_ll_utils.c
    ../Projects/gyro_module/: imualgo_axis9.lib
